# Repository tscircuit/kicad-to-circuit-json

File README.md:

# kicad-to-circuit-json

Convert KiCad schematic, symbol library, PCB, and standalone footprint files to Circuit JSON format.

## Installation

```bash
npm install kicad-to-circuit-json
# or
bun install kicad-to-circuit-json
```

## Usage

```typescript
import { KicadToCircuitJsonConverter } from "kicad-to-circuit-json"
import fs from "fs"

// Create a converter instance
const converter = new KicadToCircuitJsonConverter()

// Add KiCad files
const pcbContent = fs.readFileSync("path/to/file.kicad_pcb", "utf-8")
const schContent = fs.readFileSync("path/to/file.kicad_sch", "utf-8")

converter.addFile("example.kicad_pcb", pcbContent)
converter.addFile("example.kicad_sch", schContent)

// Run the conversion
converter.runUntilFinished()

// Get the Circuit JSON output
const circuitJson = converter.getOutput()
console.log(JSON.stringify(circuitJson, null, 2))

// Get diagnostics
console.log("Warnings:", converter.getWarnings())
console.log("Stats:", converter.getStats())
```

For a single `.kicad_mod` footprint, use the dedicated footprint converter:

```typescript
import { KicadFootprintToCircuitJsonConverter } from "kicad-to-circuit-json"
import fs from "fs"

const converter = new KicadFootprintToCircuitJsonConverter()
const footprintContent = fs.readFileSync("path/to/part.kicad_mod", "utf-8")

converter.addFile("part.kicad_mod", footprintContent)
converter.runUntilFinished()

const circuitJson = converter.getOutput()
```

Legacy KiCad 5 standalone footprints are handled through a separate best-effort
upgrade step before parsing.

For a single `.kicad_sym` symbol library, use the dedicated symbol converter:

```typescript
import { KicadSymbolToCircuitJsonConverter } from "kicad-to-circuit-json"
import fs from "fs"

const converter = new KicadSymbolToCircuitJsonConverter()
const symbolContent = fs.readFileSync("path/to/library.kicad_sym", "utf-8")

converter.addFile("library.kicad_sym", symbolContent)
converter.runUntilFinished()

const circuitJson = converter.getOutput()
```

## Architecture

The converter uses a staged pipeline architecture that mirrors the circuit-json-to-kicad converter:

### Schematic Pipeline

1. **InitializeSchematicContextStage** - Sets up coordinate transformations (KiCad → Circuit JSON)
2. **CollectLibrarySymbolsStage** - Extracts symbols and creates `source_component` + `schematic_component` entries
3. **CollectSchematicTracesStage** - Preserves individual wire drawing paths
4. **CollectSchematicAnnotationsStage** - Imports labels, text, drawings, and no-connect constraints
5. **CollectSchematicConnectivityStage** - Resolves electrical nets and links the drawing paths to logical `source_trace` records

Schematic connectivity is resolved by a pure function with explicit wire, pin,
junction, label, and implicit-power inputs. It uses `circuit-json-to-connectivity-map`
for grouping and `@tscircuit/math-utils` for geometry. Rendering stages do not
populate shared connectivity caches. Hidden `power_in` pins join the net named
by their pin name; dedicated power symbols use their Value. Power flags do not
name remote nets. A pin or wire endpoint touching another wire's interior needs
an explicit junction.

All import paths share source-component construction and terminal creation.
Numbered copper pads have source ports even without net assignments. When a
schematic and PCB are imported together, footprints reuse the schematic's source
identity through their symbol path, or an unambiguous reference when no path is
present. Shared terminals connect the schematic and PCB net records. Nonnumeric
pin identifiers are preserved in `source_port.port_hints`.

### PCB Pipeline

1. **InitializePcbContextStage** - Sets up PCB coordinate transformations
2. **CollectNetsStage** - Builds net number to name mappings
3. **CollectFootprintsStage** - Converts footprints to `pcb_component` with pads/holes
4. **CollectTracesStage** - Converts segments and connected vias to `pcb_trace.route` elements
5. **CollectViasStage** - Emits fallback `pcb_via` elements for vias not represented in trace routes
6. **CollectGraphicsStage** - Extracts board outline and silkscreen graphics

## Coordinate Transformations

The converter handles coordinate system differences between KiCad and Circuit JSON:

- **Schematic**: `scale(1/15, -1/15)` with translation (inverse of CJ→KiCad transform)
- **PCB**: `scale(1, -1)` with translation

## Supported Features

### Schematic

- ✅ Symbols/Components
- ✅ Symbol ports/pins
- ✅ Wires/traces
- ✅ Junctions
- ✅ Component properties (Reference, Value)
- ⚠️ Net labels (partial)
- ⚠️ Power symbols (partial)

### PCB

- ✅ Footprints/Components
- ✅ SMD pads
- ✅ Through-hole pads (plated holes)
- ✅ NPTH holes
- ✅ Traces/Segments
- ✅ Vias
- ✅ Board outline (Edge.Cuts)
- ✅ Silkscreen graphics
- ✅ Net mappings

## MVP Limitations

This is an MVP implementation. Some limitations include:

- Component sizes are estimated (not derived from actual symbol geometry)
- Port positions are simplified (not fully transformed relative to component)
- Trace routing is basic (segments grouped by net/layer)
- Some pad shapes may not map perfectly
- Power symbols and net labels need enhancement
- Multi-sheet schematics not fully tested

## Development

```bash
# Install dependencies
bun install

# Build the library
bun run build

# Run the Vite viewer
bun run dev

# Build the Vite site
bun run build:site

# Type check
bunx tsc --noEmit

# Test
bun test
```

## Browser Viewer

This repository now includes a small Vite app under `site/` for local inspection
and demos.

```bash
bun run dev
```

The page accepts drag-and-drop `.kicad_pcb`, `.kicad_sch`, and `.kicad_sym`
files, converts them with the local library source, and renders the resulting
Circuit JSON inside an embedded runframe iframe preview. PCB files open in the
PCB preview, while schematic and symbol library files open in the schematic
preview. The site does not need the runframe package installed locally.

## Related Projects

- [circuit-json-to-kicad](https://github.com/tscircuit/circuit-json-to-kicad) - Convert Circuit JSON to KiCad (reverse direction)
- [circuit-to-svg](https://github.com/tscircuit/circuit-to-svg) - Render Circuit JSON as SVG

## License

MIT

## KiCad design tests/repros/stm32-midi-keys/stm32_midi_keys.kicad_pcb

Board: 2 copper layers, 170.0 x 60.0 mm, 86 parts (0 on the bottom side), 68 nets.

Parts:
BZ1: Speaker/Piezo; Buzzer_12x9.5RM7.6
C1, C8: 4.7uF; C_0603_1608Metric
C2: 10uF; C_0603_1608Metric
C3: 4.7nF; C_0603_1608Metric
C4, C5, C6, C7, C11: 100nF; C_0603_1608Metric
C9: 1uF; C_0603_1608Metric
C10: 10nF; C_0603_1608Metric
C12, C13: 20pF; C_0603_1608Metric
C14, C15, C16, C17, C18: 22nF; C_0603_1608Metric
D1: PWR green; LED_0603_1608Metric
D2: Blue; LED_0603_1608Metric
D3: B5819W; D_SOD-123
F1: 500mA hold; Fuse_1206_3216Metric
FB1: 600R@100MHz; L_0603_1608Metric
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: SWD; PinHeader_2x05_P1.27mm_Vertical
J3: Chain_Left; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J4: Chain_Right; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J5: OLED_I2C; PinHeader_1x04_P2.54mm_Vertical
J6: GPIO; PinHeader_1x06_P2.54mm_Vertical
J7: MIDI_OUT; Jack_3.5mm_CUI_SJ1-3523N_Horizontal
JP1: PULLUP_EN; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: AO3400A; SOT-23
R1, R8: 1k; R_0603_1608Metric
R2, R3: 5.1k; R_0603_1608Metric
R4: 1M; R_0603_1608Metric
R5, R6: 22Ω; R_0603_1608Metric
R7, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R25: 10k; R_0603_1608Metric
R23, R24: 4.7k; R_0603_1608Metric
R26: 33Ω; R_0603_1608Metric
R27: 10Ω; R_0603_1608Metric
R28: 100Ω; R_0603_1608Metric
R29: 100k; R_0603_1608Metric
SW1: BOOT; SW_Push_1P1T_XKB_TS-1187A
SW2: RESET; SW_Push_1P1T_XKB_TS-1187A
TK1: Touch C; TouchKey_C
TK2: Touch D; TouchKey_D
TK3: Touch E; TouchKey_E
TK4: Touch F; TouchKey_F
TK5: Touch G; TouchKey_G
TK6: Touch A; TouchKey_A
TK7: Touch B; TouchKey_B
TK8: Touch C#; TouchKey_Cs
TK9: Touch D#; TouchKey_Ds
TK10: Touch F#; TouchKey_Fs
TK11: Touch G#; TouchKey_Gs
TK12: Touch A#; TouchKey_As
TK13: Touch OCT +; TouchPad_Octave_Up
TK14: Touch OCT -; TouchPad_Octave_Down
U1: STM32F072CBT6; LQFP-48_7x7mm_P0.5mm
U2: AP2112K-3.3; SOT-23-5
U3: USBLC6-2SC6; SOT-23-6
Y1: 8MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3VA: C9.1, C10.1, FB1.2, U1.9
+3V3: C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, FB1.1, J2.1, J3.1, J4.1, J5.2, J6.1, JP1.1, R1.1, R26.1, SW1.2, U1.1, U1.24, U1.36, U1.48, U2.5
+5V: BZ1.1, C1.1, D3.1, F1.2, U2.1, U2.3
/Expansion/MIDI_SINK: J7.T, R27.2
/Expansion/MIDI_SRC: J7.R, R26.2
/Keys/PAD_A: R14.2, TK6.1
/Keys/PAD_AS: R20.2, TK12.1
/Keys/PAD_B: R15.2, TK7.1
/Keys/PAD_C: R9.2, TK1.1
/Keys/PAD_CS: R16.2, TK8.1
/Keys/PAD_D: R10.2, TK2.1
/Keys/PAD_DN: R22.2, TK14.1
/Keys/PAD_DS: R17.2, TK9.1
/Keys/PAD_E: R11.2, TK3.1
/Keys/PAD_F: R12.2, TK4.1
/Keys/PAD_FS: R18.2, TK10.1
/Keys/PAD_G: R13.2, TK5.1
/Keys/PAD_GS: R19.2, TK11.1
/Keys/PAD_UP: R21.2, TK13.1
/USB/CC1: J1.A5, R2.1
/USB/CC2: J1.B5, R3.1
/USB/SHIELD: C3.1, J1.S1, R4.1
/USB/USB_CONN_DM: J1.A7, J1.B7, R5.1, U3.1, U3.6
/USB/USB_CONN_DP: J1.A6, J1.B6, R6.1, U3.3, U3.4
BOOT0: R7.1, SW1.1, U1.44
CHAIN_INT: J3.4, J4.4, R25.2, U1.41
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.1, D2.1, J1.A1, J1.A12, J1.B1, J1.B12, J2.3, J2.5, J2.9, J3.5, J4.5, J5.1, J6.6, J7.S, Q1.2, R2.2, R3.2, R4.2, R7.2, R29.2, SW2.1, U1.8, U1.23, U1.35, U1.47, U2.2, U3.2, Y1.2, Y1.4
GPIO_PA10: J6.2, U1.31
GPIO_PC13: J6.3, U1.2
GPIO_PC14: J6.4, U1.3
GPIO_PC15: J6.5, U1.4
I2C_SCL: J3.3, J4.3, J5.3, R24.2, U1.45
I2C_SDA: J3.2, J4.2, J5.4, R23.2, U1.46
KEY_A: R14.1, U1.18
KEY_AS: R20.1, U1.19
KEY_B: R15.1, U1.22
KEY_C: R9.1, U1.39
KEY_CS: R16.1, U1.40
KEY_D: R10.1, U1.42
KEY_DS: R17.1, U1.10
KEY_E: R11.1, U1.11
KEY_F: R12.1, U1.12
KEY_FS: R18.1, U1.14
KEY_G: R13.1, U1.15
KEY_GS: R19.1, U1.16
LED_USER: R8.1, U1.21
MIDI_TX: R27.1, U1.30
NRST: C11.1, J2.10, SW2.2, U1.7
unnamed: BZ1.2, D3.2, Q1.3
unnamed: D1.2, R1.2
unnamed: D2.2, R8.2
unnamed: JP1.2, R23.1, R24.1, R25.1
unnamed: Q1.1, R28.2, R29.1
OCT_DN: R22.1, U1.26
OCT_UP: R21.1, U1.25
OSC_IN: C12.1, U1.5, Y1.1
OSC_OUT: C13.1, U1.6, Y1.3
SPK_PWM: R28.1, U1.29
SWCLK: J2.4, U1.37
SWDIO: J2.2, U1.34
TSC_G1_CS: C14.1, U1.13
TSC_G2_CS: C15.1, U1.17
TSC_G3_CS: C16.1, U1.20
TSC_G5_CS: C17.1, U1.43
TSC_G6_CS: C18.1, U1.27
USB_DM: R5.2, U1.32
USB_DP: R6.2, U1.33
VBUS: F1.1, J1.A4, J1.A9, J1.B4, J1.B9, U3.5

## Commit log (part)

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2026-06-07 Revert "Add standalone `.kicad_mod` footprint conversion with regression test and website support"
2026-06-07 Revert "Add standalone `.kicad_mod` footprint conversion with regression test and website support" (#133)
2026-06-07 v0.0.89
2026-06-07 feat: add standalone footprint converter for KiCad .kicad_mod files
    - Updated README to include information about the new KicadFootprintToCircuitJsonConverter.
    - Implemented KicadFootprintToCircuitJsonConverter class to handle conversion of standalone footprint files.
    - Added methods for adding files, initializing context, and retrieving output and warnings.
    - Created tests for the new converter, including validation of output structure and SVG snapshot generation.
    - Added sample .kicad_mod file for testing purposes.
2026-06-07 refactor: improve code formatting and simplify snapshot file writing
2026-06-07 v0.0.90
2026-06-08 Added KicadSymbolToCircuitJsonConverter
2026-06-08 Added KicadSymbolToCircuitJsonConverter (#135)
2026-06-08 v0.0.91
2026-06-08 Add the schematic_symbol element in the circuit-json output
2026-06-08 Add the schematic_symbol element in the circuit-json output (#136)
2026-06-08 v0.0.92
2026-06-09 fix(site): support standalone .kicad_mod and .kicad_sym files in the browser converter preview
2026-06-09 fix(app): clean up formatting and improve readability in the App component
2026-06-09 v0.0.93
2026-06-11 Add CM5IO symbol-library circuit JSON and SVG snapshots
2026-06-11 Add CM5IO symbol-library circuit JSON and SVG snapshots (#138)
    * Add CM5IO symbol-library circuit JSON and SVG snapshots
    * Add CM5IO symbol-library circuit JSON and SVG snapshots
2026-06-11 v0.0.94
2026-06-14 Preserve KiCad silkscreen pin-1 markers and graphic stroke widths during footprint conversion
2026-06-14 Preserve KiCad silkscreen pin-1 markers and graphic stroke widths during footprint conversion (#139)
2026-06-14 v0.0.95
2026-06-15 Fix missing PCB vias in viewer
2026-06-15 format
2026-06-15 update snapshots
2026-06-15 Update repro snapshots
2026-06-15 v0.0.96
2026-06-16 Normalize geometry helpers with named placement contexts
2026-06-16 Refactors KiCad-to-Circuit JSON geometry conversion helpers to use named parameter objects and explicit placement contexts (#141)
2026-06-16 v0.0.97
2026-06-16 update kicadts
2026-06-17 Change symbol-library reference/value text color to rgb(0, 100, 100)
2026-06-17 Infer pin headers in symbol-library source components
2026-06-17 chore: update kicadtsi
2026-06-17 Classify SW references as simple_switch (#143)
2026-06-17 v0.0.98
2026-06-17 refactor: centralize repo color constants
2026-06-19 Use zone outlines for copper pours
2026-06-20 chore: bump kicadts dependency
2026-06-20 chore: bump kicadts dependency (#148)
2026-06-20 v0.0.99
2026-06-22 v0.0.100
2026-06-22 Preserve reference text orientation in standalone footprint conversions
2026-06-22 patch
2026-06-22 pass
2026-06-22 Preserve reference text orientation in standalone footprint conversions (#150)
    * Preserve reference text orientation in standalone footprint conversions
    * patch
    * pass
2026-06-22 v0.0.101
2026-06-22 fix: correct symbol-library arc orientation and honor hidden pin names
2026-06-22 refactor
2026-06-22 Infer pin headers in symbol-library source components (#145)
    * Infer pin headers in symbol-library source components
    * chore: update kicadtsi
    * update
2026-06-22 v0.0.102
2026-06-23 Support simple_test_point inference for TP symbols and footprints
2026-06-23 Infer simple_switch for KiCad switch footprints and symbols
2026-06-23 fix: correct symbol-library arc orientation and honor hidden pin names and refactor to use transformation-matrix (#151)
    * fix: correct symbol-library arc orientation and honor hidden pin names
    * refactor
2026-06-23 v0.0.103
2026-06-23 Preserve KiCad text font sizes during Circuit JSON conversion
2026-06-23 Preserve KiCad text font sizes during Circuit JSON conversion (#154)
    * Preserve KiCad text font sizes during Circuit JSON conversion
    * patch
2026-06-23 v0.0.104
2026-06-24 Support simple_test_point inference for TP symbols and footprints (#152)
2026-06-24 v0.0.105
2026-06-24 Add deterministic fallback identities for KiCad fp_poly conversion
2026-06-24 Update kicadts to accept fp_poly without uuid/tstamp (#155)
    * Add deterministic fallback identities for KiCad fp_poly conversion
    * patch
2026-06-24 v0.0.106
2026-06-24 update schematic-symbol
2026-06-30 test: repro for custom pads dropping their anchor shape
    A KiCad "smd custom" pad's copper is the union of its anchor shape (the
    rect/circle at the pad's at + size) and its primitive graphics, but the
    converter emits only the primitives and drops the anchor. On SOT-89-3
    that anchor is the collector-tab neck reaching toward the leads, so the
    converted tab loses it -- pad 2 only reaches x=-1.125 instead of -2.6.
    Includes a visual snapshot of the converted footprint; on this branch
2026-06-30 test: repro for custom pads dropping their anchor shape (#157)
    A KiCad "smd custom" pad's copper is the union of its anchor shape (the
    rect/circle at the pad's at + size) and its primitive graphics, but the
    converter emits only the primitives and drops the anchor. On SOT-89-3
    that anchor is the collector-tab neck reaching toward the leads, so the
    converted tab loses it -- pad 2 only reaches x=-1.125 instead of -2.6.
    Includes a visual snapshot of the converted footprint; on this branch
2026-06-30 v0.0.107
2026-06-30 fix: include the anchor shape of KiCad custom pads
    A custom pad's copper is the union of its anchor shape (the rect/circle
    at the pad's at + size) and its primitive graphics. The converter only
    emitted the primitives and dropped the anchor, so e.g. the SOT-89-3
    collector tab lost the neck that reaches toward the leads.
    Emit the anchor (rect/circle, honoring rotation) when it actually adds
    copper -- i.e. when it extends past the primitives' footprint -- and skip
